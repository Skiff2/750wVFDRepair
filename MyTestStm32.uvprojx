# Keil uVision project MyTestStm32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyTestStm32 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: .\MyTestSTM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group YouTube3Phase
    ./: MainW3p.c
  group Libs
    ./: fonts.c ssd1306.c ssd1306_i2c.c fonts.h ssd1306.h ssd1306_i2c.h flash.c flash.h
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
